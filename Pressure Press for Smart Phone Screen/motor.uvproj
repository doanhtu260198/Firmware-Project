# Keil uVision project motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7323 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  asm include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./scr/: main.c timer.c LEDmultiplexing.c thread.c exti.c pwm.c adc.c EEPROM.c uart.c
